## samples/boards/microbit/zip_halo/sample.yaml
```yaml
sample:
  name: ZIP Halo
tests:
  test:
    platform_whitelist: bbc_microbit
    tags: samples
```
